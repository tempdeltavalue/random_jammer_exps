options:
  parameters:
    generate_options: qt_gui
    id: temp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/tempdelta/Desktop/jammer_exp/Bach_C_minor_Passacaglia_Variation_2.wav
    repeat: 'True'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"modulated"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"original"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"temp"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"demodulated"'
    type: float
  states: {}
- name: vocoder_ulaw_encode_sb_0
  id: vocoder_ulaw_encode_sb
  parameters: {}
  states: {}

connections:
- [blocks_float_to_short_0, '0', vocoder_ulaw_encode_sb_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_waterfall_sink_x_2, '0']
- [blocks_uchar_to_float_1, '0', qtgui_waterfall_sink_x_1_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_short_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_constellation_modulator_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_waterfall_sink_x_0, '0']
- [vocoder_ulaw_encode_sb_0, '0', blocks_uchar_to_float_1, '0']
- [vocoder_ulaw_encode_sb_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
